<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>RAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>BOOT</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\source\Cam.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Cam.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\CCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\CCD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\framework2016.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\HMI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\HMI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Mag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Mag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Motor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\OLED.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\OLED_UI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\OLED_UI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\LPLD\DEV\Setting.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\UART.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\UI_Operation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\UI_Operation.h</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\k60_card.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\MK60DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\relocate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\relocate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\startup_K60.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\system_MK60DZ10.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\system_MK60DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\typedef.h</name>
      </file>
    </group>
    <group>
      <name>LPLD</name>
      <file>
        <name>$PROJ_DIR$\LPLD\DEV\DEV_MMA8451.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\DEV\DEV_MMA8451.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\HW\HW_I2C.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\HW\HW_I2C.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\HW\HW_MCG.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\HW\HW_MCG.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LPLD\LPLD_Drivers.h</name>
      </file>
    </group>
  </group>
</project>


